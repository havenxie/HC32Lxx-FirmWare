# Keil uVision project test.uvprojx, settings and files
target HC32L110_Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: L005_ICC_N29 +hex
  c flags: Optim=2 oTime=1 wLevel=2
  c include: ..\Src;..\lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../Src/: main.c SlaveMcu.c IRQ.c delay.c
  group HD_Lib
    ../lib/src/: hc32l110_gpio.c hc32l110_rcc.c hc32l110_msic.c hc32l110_uart.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
